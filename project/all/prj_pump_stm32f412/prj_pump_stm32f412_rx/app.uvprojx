# Keil uVision project app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F412RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: ..\mk.bat 1 "$L@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F412Rx,BOARD_PUMP_F412RET6,OS_KERNEL=1
  c misc: --diag_suppress=177,1296
  c include: ../user;../../../../device;../../../../system;../../../../platform/chip/st/stm32f4xx;../../../../platform/chip/st/stm32f4xx/inc;../../../../platform/chip/st/stm32f4xx/inc/Legacy;../../../../platform/os;../../../../platform/core/inc
  asm define: OS_KERNEL=1
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group user
    ../user/: myCfg.h lock.h RTX_Config.c RTX_Config.h rtx_lib.c task.c task_com.c task_dev.c board.c
    ../../../../system/: error.h data.h paras.h
    ./: startup_stm32f412rx.s
  group device
    ../../../../device/: at24cxx.c buzzer.c led.c ms4525.c n950.c valve.c
    ../../../../device/bmp280/: bmp280.c bmp280_ori.c
  group system
    ../../../../system/: log.c upgrade.c pkt.c paras.c lock.c date.c com.c nvm.c msg.c main_app.c data.h notice.c power.c wdog.c
  group chip/drv
    ../../../../platform/chip/st/stm32f4xx/drv/: delay.c flash.c i2c.c uart.c clk.c jump.c gpio.c pwm.c htimer.c
  group chip/stm32f4xx
    ../../../../platform/chip/st/stm32f4xx/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_it.c stm32f4xx_sys.c
  group os
    ../../../../platform/os/rtx/: os_systick.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../../../platform/core/asm/: irq_cm4f_armcc.s
software components: CMSIS:CORE 5.4.0
