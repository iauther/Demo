# Keil uVision project test.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.6.1
  cpu: IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) IROM(0x08000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BOARD_JKCARE_V03
  c misc: --diag_suppress=177,1296
  c include: .\user;..\..\..\system;..\..\..\device;..\..\..\platform\os;..\..\..\platform\chip\mtk;..\..\..\platform\chip\mtk\inc;..\..\..\platform\chip\mtk\mt2523\inc;..\..\..\platform\core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\user\flash.sct
  group user
    ./user/: board.c myCfg.h evt.h task.c lock.h task_test.c RTX_Config.h memory_map.h msdc_custom_config.h rtx_lib.c RTX_Config.c RTE_Components.h hal_feature_config.h
  group system
    ../../../system/: main_app.c log.c msg.c retarget.c
  group device
    ../../../device/temp/: temp.c
    ../../../device/temp/ams/: as62xx.c
    ../../../device/temp/mlx/: mlx90632.c mlx90632_extended_meas.c
    ../../../device/: tca6424a.c led.c
  group chip/drv
    ../../../platform/chip/mtk/drv/: delay.c gpio.c htimer.c i2c.c uart.c flash.c clk.c si2c.c
  group chip/mt2523
    ../../../platform/chip/mtk/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_aes.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_dwt.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c mt2523_system.c mt2523_startup_armcc.s
    ../../../platform/chip/mtk/mt2523/src_core/: hal_clock.c hal_cm4_topsm.c hal_cm4_topsm_internal.c hal_dsp_topsm.c hal_sleep_driver.c hal_sleep_manager.c hal_sys_topsm.c
  group platform/os
    ../../../platform/os/rtx/: rtx_timer.c rtx_thread.c rtx_system.c rtx_semaphore.c rtx_mutex.c rtx_msgqueue.c rtx_mempool.c rtx_memory.c rtx_kernel.c rtx_evr.c rtx_evflags.c rtx_delay.c os_systick.c
  group platform/core
    ../../../platform/core/asm/: irq_cm4f_armcc.s
