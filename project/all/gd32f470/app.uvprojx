# Keil uVision project app.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: go.bat  @L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470,OS_KERNEL=1
  c misc: --diag_suppress=111,177,550
  c include: ./user;../../../device;../../../system;../../../system/net;../../../system/net/protocols/mqtt;../../../platform/chip/gd/gd32f4xx/dal;../../../platform/chip/gd/gd32f4xx/inc;../../../platform/os;../../../platform/core/inc;../../../midware/modbus;../../../midware/ini;../../../midware/json;../../../midware/mem;../../../midware/fs/fatfs;../../../midware/fs/yaffs2;../../../midware/dsp;../../../midware/utils;../../../midware/mqtt;../../../midware/mqtt/clink/core;../../../midware/mqtt/clink/core/utils;../../../midware/mqtt/clink/core/sysdep;../../../midware/mqtt/clink/portfiles;../../../midware/mqtt/clink/components/ntp;../../../midware/mqtt/clink/components/ota;../../../midware/mqtt/clink/components/data-model;../../../midware/mqtt/clink/external/mbedtls/include
  asm define: OS_KERNEL=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: cfg.h evt.h dflt.c board.c test.c gd32f4xx_it.c platform.h gd32f4xx_libopt.h system_gd32f4xx.c startup_gd32f450_470.s task.h
    ./user/task/: task_comm_recv.c task_data_cap.c task_data_proc.c task_comm_send.c task_nvm.c task_polling.c
  group device
    ../../../device/: ads9120.c ecxxx.c sflash.c sd30xx.c dac.c pt1000.c
  group system
    ../../../system/: comm.c lock.c log.c main.c msg.c nvm.c paras.c pkt.c rbuf.c upgrade.c task.c date.c retarget.c list.c rs485.c fs.c power.c rtc.c app.c md5.c cmd.c
  group system/net
    ../../../system/net/: net.c netio.c
    ../../../system/net/protocols/mqtt/: mqtt.c mqtt_ali.c mqtt_self.c
  group os/rtx5
    ../../../platform/os/rtx/: os_systick.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c rtx_lib.c RTX_Config.c RTX_Config.h
    ../../../platform/core/asm/: irq_cm4f_armcc.s
  group chip/dal
    ../../../platform/chip/gd/gd32f4xx/dal/: dal.c dal_adc.c dal_dac.c dal_delay.c dal_gpio.c dal_spi.c dal_uart.c dal_nor.c dal_jump.c dal_timer.c dal_pwm.c dal_sd.c dal_nand.c dal_rtc.c dal_pmu.c dal_si2c.c dal_sdram.c dal_wdg.c
  group chip/gd32f4xx
    ../../../platform/chip/gd/gd32f4xx/src/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group midware/mem
    ../../../midware/mem/: mem.c rtx_mem.c tiny.c
  group midware/json
    ../../../midware/json/: cJSON.c json.c
  group midware/fs/fatfs
    ../../../midware/fs/fatfs/: diskio.c fatfs.c ff.c ffsystem.c ffunicode.c
  group midware/fs/yaffs2
    ../../../midware/fs/yaffs2/: qsort.c yaffs_allocator.c yaffs_attribs.c yaffs_bitmap.c yaffs_cache.c yaffs_checkptrw.c yaffs_ecc.c yaffs_endian.c yaffs_error.c yaffs_guts.c yaffs_hweight.c yaffs_nameval.c yaffs_nand.c yaffs_nand_drv.c yaffs_nor_drv.c yaffs_osglue.c yaffs_packedtags1.c yaffs_packedtags2.c yaffs_summary.c yaffs_tagscompat.c yaffs_tagsmarshall.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c yaffsfs.c yaffs2.c
  group midware/fs/stdfs
    ../../../midware/fs/stdfs/: stdfs.c
  group midware/ini
    ../../../midware/ini/: dictionary.c iniparser.c
    ../../../system/: ini.c
  group midware/dsp
    ../../../midware/dsp/: dsp.c
  group midware/utils
    ../../../midware/utils/: utils_hmac.c utils_base64.c utils_md5.c utils_sha1.c utils_sha256.c
  group midware/clink
    ../../../midware/mqtt/clink/core/: aiot_mqtt_api.c aiot_state_api.c aiot_mqtt_props_api.c
    ../../../midware/mqtt/clink/core/utils/: core_auth.c core_diag.c core_global.c core_http.c core_log.c core_sha256.c core_string.c
    ../../../midware/mqtt/clink/core/sysdep/: core_adapter.c core_sysdep.c
    ../../../midware/mqtt/clink/portfiles/: aiot_at_api.c hw_at_impl.c net_at_impl.c sys_os_impl.c at_port.c
    ../../../midware/mqtt/clink/portfiles/module/: ecxxx_tcp.c ecxxx_ssl.c
    ../../../midware/mqtt/clink/external/: ali_ca_cert.c
    ../../../midware/mqtt/clink/components/data-model/: aiot_dm_api.c
    ../../../midware/mqtt/clink/components/ntp/: aiot_ntp_api.c
    ../../../midware/mqtt/clink/components/ota/: ota_md5.c aiot_ota_api.c
  group midware/mbedtls
    ../../../midware/mqtt/clink/external/mbedtls/library/: aes.c asn1parse.c base64.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c debug.c entropy.c error.c md.c md_wrap.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c platform_util.c rsa.c rsa_internal.c sha1.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_tls.c x509.c x509_crt.c
