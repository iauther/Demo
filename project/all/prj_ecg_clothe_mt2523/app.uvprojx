# Keil uVision project app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MT2523,OS_KERNEL=1
  c include: ./cfg;./user;../../../device;../../../system;../../../platform/os;../../../platform/core/inc;../../../platform/chip/mtk;../../../platform/chip/mtk/inc;../../../platform/chip/mtk/tools/inc;../../../platform/chip/mtk/mt2523/inc
  asm define: OS_KERNEL=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\cfg\flash.sct
  group sys
    ../../../system/: log.c upgrade.c lock.c msg.c rbuf.c retarget.c sys.c main_app.c
  group user
    ./user/: board.c task.c task_chk.c task_com.c task_dev.c
  group device
    ../../../device/bio/: ad8233.c ads129x.c ads129x_paras.c ads8866.c bio.c
    ../../../device/bmi160/: bmi160.c bmi160_ori.c
    ../../../device/: dev.c led.c sim89xx.c tca6424a.c
  group os/rtx
    ../../../platform/os/rtx/: os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group chip/drv
    ../../../platform/chip/mtk/drv/: delay.c gpio.c i2c.c packet.c spim.c spis.c timer.c uart.c clk.c e2p.c jump.c
  group chip/core
    ../../../platform/core/asm/: irq_cm4f_armcc.s
  group chip/mt2523
    ../../../platform/chip/mtk/mt2523/src/: hal_eint.c hal_eint_internal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_log.c hal_misc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_rtc.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c mt2523_startup_armcc.s mt2523_system.c hal_clock_internal.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_flash_custom_sfi.c hal_flash_combo_init.c hal_flash_cfi.c hal_emi.c hal_g2d.c hal_cache.c hal_cache_internal.c hal_aes.c hal_flash_disk.c
    ../../../platform/chip/mtk/mt2523/src_core/: hal_clock.c hal_cm4_topsm.c hal_cm4_topsm_internal.c hal_dsp_topsm.c hal_sleep_driver.c hal_sleep_manager.c hal_sys_topsm.c
software components: CMSIS:CORE 5.4.0
