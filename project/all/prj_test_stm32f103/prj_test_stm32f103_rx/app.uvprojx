# Keil uVision project app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TEST_BOARD_3IN1,USE_HAL_DRIVER,STM32F103xE,OS_KERNEL=1
  c misc: --diag_suppress=177,1296
  c include: ../user;../../../../device;../../../../system;../../../../platform/chip/st/stm32f1xx;../../../../platform/chip/st/stm32f1xx/inc;../../../../platform/os;../../../../platform/core/inc
  asm define: OS_KERNEL=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: myCfg.h lock.h RTX_Config.c RTX_Config.h rtx_lib.c task.c board.c task_test.c stm32f1xx_hal_conf.h task_tcp232.c
    ../../../../system/: error.h
    ./: startup_stm32f103xe.s
  group device
    ../../../../device/: st7789.c tcp232.c
  group system
    ../../../../system/: log.c lock.c date.c msg.c main_app.c font.c lcd.c key.c
  group chip/drv
    ../../../../platform/chip/st/stm32f1xx/drv/: delay.c i2c.c uart.c clk.c gpio.c adc.c spi.c
  group chip/stm32f1xx
    ../../../../platform/chip/st/stm32f1xx/src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_it.c stm32f1xx_sys.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group os
    ../../../../platform/os/rtx/: os_systick.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../../../platform/core/asm/: irq_cm3_armcc.s
software components: CMSIS:CORE 5.4.0
