# Keil uVision project app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F412Zx,OS_KERNEL=1
  c include: ./cfg;./user;../../../device;../../../system;../../../platform/os;../../../platform/core/inc;../../../platform/chip/st;../../../platform/chip/st/stm32f4xx/inc;../../../platform/chip/st/stm32f4xx/inc/Legacy
  asm define: OS_KERNEL=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group sys
    ../../../system/: log.c upgrade.c lock.c msg.c rbuf.c retarget.c sys.c main_app.c paras.c pkt.c
  group user
    ./user/: board.c task.c task_com.c task_dev.c task_misc.c
  group device
    ../../../device/: ms4525.c n950.c valve.c at24cxx.c
    ../../../device/bmp280/: bmp280.c bmp280_ori.c
  group os/rtx
    ../../../platform/os/rtx/: os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group chip/drv
    ../../../platform/chip/st/drv/: delay.c flash.c gpio.c i2c.c spi.c uart.c jump.c clk.c si2c.c pwm.c wdg.c htimer.c
  group chip/core
    ../../../platform/core/asm/: irq_cm4f_armcc.s
  group chip/stm32f4xx
    ../../../platform/chip/st/stm32f4xx/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_it.c stm32f4xx_sys.c stm32f4xx_startup.s stm32f4xx_hal_iwdg.c
software components: CMSIS:CORE 5.4.0
