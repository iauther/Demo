# Keil uVision project app.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,OS_KERNEL=3,NDEBUG
  c misc: --diag_suppress=177,1296,550
  c include: ./user;../../../device;../../../system;../../../platform/chip/st/stm32h7xx;../../../platform/chip/st/stm32h7xx/inc;../../../platform/os;../../../platform/core/inc;../../../midware/lwip/sys;../../../midware/lwip/src/include;../../../midware/modbus;../../../midware/fs/yaffs2;../../../midware/json
  asm define: OS_KERNEL=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: cfg.h platform.h evt.h board.c test.c
    ./user/task/: task_comm.c task_polling.c
  group system
    ../../../system/: comm.c lock.c log.c main.c msg.c nvm.c paras.c pkt.c rbuf.c upgrade.c net.c task.c sys.c date.c retarget.c snd.c list.c cap.c
  group os/rtx5
    ../../../platform/os/rtx/: os_systick.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c rtx_lib.c RTX_Config.c RTX_Config.h
    ../../../platform/core/asm/: irq_armv7m.s
  group os/freertos
    ../../../platform/os/freertos/portable/: heap_4.c port.c
    ../../../platform/os/freertos/: cmsis_os2.c croutine.c list.c queue.c tasks.c timers.c event_groups.c stream_buffer.c
  group chip/dal
    ../../../platform/chip/gd/gd32f4xx/dal/: adc.c dac.c dal.c delay.c flash.c gpio.c i2c.c jump.c spi.c uart.c
  group chip/gd32f4xx
    ../../../platform/chip/gd/gd32f4xx/src/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
