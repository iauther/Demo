# Keil uVision project boot.uvprojx, settings and files
target boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: go.bat  @L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470,BOOTLOADER=1
  c misc: --diag_suppress=177,1296,550
  c include: ./user;../../../device;../../../system;../../../platform/chip/gd/gd32f4xx/dal;../../../platform/chip/gd/gd32f4xx/inc;../../../platform/os;../../../platform/core/inc;../../../midware/modbus;../../../midware/json;../../../midware/xmem;../../../midware/fs/fatfs;../../../midware/fs/yaffs2
  asm define: BOOTLOADER=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: cfg.h platform.h startup_gd32f450_470.s gd32f4xx_it.c gd32f4xx_libopt.h system_gd32f4xx.c dflt.c
  group device
    ../../../device/: ecxxx.c sflash.c sd30xx.c
  group system
    ../../../system/: log.c pkt.c upgrade.c date.c retarget.c lock.c rs485.c main.c boot.c rtc.c md5.c
  group chip/dal
    ../../../platform/chip/gd/gd32f4xx/dal/: dal.c dal_delay.c dal_gpio.c dal_uart.c dal_nor.c dal_jump.c
  group chip/gd32f4xx
    ../../../platform/chip/gd/gd32f4xx/src/: gd32f4xx_dbg.c gd32f4xx_dma.c gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_usart.c gd32f4xx_spi.c
