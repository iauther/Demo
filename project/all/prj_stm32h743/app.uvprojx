# Keil uVision project app.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,OS_KERNEL=3,NDEBUG
  c misc: --diag_suppress=177,1296,550
  c include: ./user;../../../device;../../../system;../../../platform/chip/st/stm32h7xx/dal;../../../platform/chip/st/stm32h7xx/inc;../../../platform/os;../../../platform/core/inc;../../../midware/lwip/sys;../../../midware/lwip/src/include;../../../midware/modbus;../../../midware/fs/yaffs2;../../../midware/json;../../../midware/modbus;../../../midware/xmem
  asm define: OS_KERNEL=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group user
    ./user/: cfg.h platform.h evt.h stm32h7xx_hal_conf.h lwipopts.h stm32h7xx_it.c system_stm32h7xx.c startup_stm32h743xx.s board.c test.c dflt.c
    ./user/task/: task_comm_recv.c task_comm_send.c task_data_cap.c task_data_proc.c task_polling.c
  group device
    ../../../device/eth/: eth.c lan8742.c
    ../../../device/snd/: adau197x.c pcm186x.c
  group system
    ../../../system/: comm.c lock.c log.c main.c msg.c nvm.c paras.c pkt.c rbuf.c upgrade.c net.c task.c sys.c date.c retarget.c snd.c list.c fs.c json.c mb.c
  group os/rtx5
    ../../../platform/os/rtx/: os_systick.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c rtx_lib.c RTX_Config.c RTX_Config.h
    ../../../platform/core/asm/: irq_armv7m.s
  group os/freertos
    ../../../platform/os/freertos/portable/: heap_4.c xport.c
    ../../../platform/os/freertos/: cmsis_os2.c croutine.c xlist.c xqueue.c tasks.c timers.c event_groups.c stream_buffer.c
  group chip/dal
    ../../../platform/chip/st/stm32h7xx/dal/: dal_adc.c dal_adc2.c dal_adc3.c dal_delay.c dal_flash.c dal_gpio.c dal_i2c.c dal_jump.c dal_spi.c dal_uart.c dal_eth.c dal_sdram.c dal.c dal_si2c.c dal_mdma.c dal_sai.c dal_tmr.c dal_nand.c dal_nand2.c dal_cap.c
  group chip/stm32h7xx
    ../../../platform/chip/st/stm32h7xx/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_smbus_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c
  group midware/lwip
    ../../../midware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../midware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem0.c memp.c netif.c pbuf.c raw.c stats.c sys0.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../midware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../../../midware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../midware/lwip/sys/os/: sys_arch.c
  group midware/yaffs2
    ../../../midware/fs/yaffs2/: yaffs_attribs.c yaffs_error.c yaffs_hweight.c yaffs_nand_drv.c yaffsfs.c yaffs_osglue.c yaffs_allocator.c yaffs_bitmap.c yaffs_cache.c yaffs_checkptrw.c yaffs_ecc.c yaffs_endian.c yaffs_guts.c yaffs_nameval.c yaffs_nand.c yaffs_nor_drv.c yaffs_packedtags1.c yaffs_packedtags2.c yaffs_summary.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c yaffs_tagscompat.c yaffs_tagsmarshall.c qsort.c yaffsfs.h
  group midware/json
    ../../../midware/json/: cJSON.c cJSON.h
  group midware/modbus
    ../../../midware/modbus/: modbus.c
  group midware/xmem
    ../../../midware/xmem/: rtx_mem.c xmem.c
