# Keil uVision project boot.uvprojx, settings and files
target boot (6180000::V6.18::ARMCLANG)
  device: STM32F412RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,BOARD_PUMP_F412RET6
  c include: ../user;../../../../device;../../../../system;../../../../platform/chip/st;../../../../platform/chip/st/stm32f4xx/inc;../../../../platform/chip/st/stm32f4xx/inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group user
    ../user/: myCfg.h board.c
    ../../../../system/: error.h data.h
  group device
    ../../../../device/: at24cxx.c buzzer.c led.c
    ../../../../device/temp/ams/: as62xx.c
    ../../../../device/temp/mlx/: mlx90632.c mlx90632_extended_meas.c
  group system
    ../../../../system/: log.c upgrade.c main_boot.c pkt.c paras.c lock.c date.c com.c nvm.c notice.c power.c wdog.c
  group chip/drv
    ../../../../platform/chip/st/drv/: delay.c flash.c i2c.c uart.c clk.c jump.c gpio.c htimer.c
  group chip/stm32f4xx
    ../../../../platform/chip/st/stm32f4xx/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_it.c stm32f4xx_sys.c stm32f4xx_startup.s
software components: CMSIS:CORE 5.6.0
